DESCRIPTION = "Mapio genimage image"

require mapio-genimage-common.inc

GENIMAGE_ROOTFS_IMAGE = "mapio-image"
